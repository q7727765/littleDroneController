# Keil uVision project littleDroneController.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: littleDroneController +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F103xB,u8=uint8_t,u16=uint16_t,u32=uint32_t,USE_HAL_DRIVER
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Inc;..\Src;..\Src\driver;..\Src\scheduler
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group LIB
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group SYS
    ../Src/: system_stm32f1xx.c stm32f1xx_hal_msp.c stm32f1xx_it.c sys.c usart.c delay.c
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group DRIVER
    ../Src/driver/: nrf24l01.c
  group SRC
    ../Src/scheduler/: scheduler.c
    ../Src/: config_tasks.c HAL_rc.c main.c rc_filter.c schedule_tasks.c stmflash.c
